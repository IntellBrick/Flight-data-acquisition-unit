# Keil uVision project stm32h723_can1.uvprojx, settings and files
target stm32h723_can1 (6210000::V6.21::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x24000000,0x00050000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(200000000) ELITTLE
  output: stm32h723_can1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: STM32H723xx,USE_HAL_DRIVER,USE_PWR_LDO_SUPPLY,CANARD_ENABLE_DEADLINE=1
  c misc: -std=c11 -Wno-everything -Wall
  c include: ..\App;..\Core\Inc;..\ThirdParty\libcanard;..\ThirdParty\DSDL\include;..\ThirdParty\FatFs\source;..\Drivers\STM32H7xx_HAL_Driver\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32H7xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x24000000 size 0x50000
  scatter file: .\stm32h723_can1.sct
  group Core
    ../Core/Src/: board.c main.c sd_diskio.c
    ../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    ../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h723xx.s
  group App
    ../App/: acquisition.c log_record.c sd_log.c status_led.c
  group STM32H7 HAL
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_sdmmc.c
  group libcanard
    ../ThirdParty/libcanard/: canard.c
  group DroneCAN DSDL
    ../ThirdParty/DSDL/src/: uavcan.equipment.air_data.RawAirData.c uavcan.equipment.gnss.ECEFPositionVelocity.c uavcan.equipment.gnss.Fix2.c uavcan.protocol.dynamic_node_id.Allocation.c uavcan.protocol.NodeStatus.c uavcan.Timestamp.c
  group FatFs
    ../ThirdParty/FatFs/source/: ff.c
